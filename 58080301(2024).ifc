Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 50356248-56fd-404e-bfe4-5503dd407272, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 58080301(2024).ifc
Time: 2025-01-29T23:45:52
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_379360_1
InPort_379360_3

# IfcFlowController: 58080301(2024):58080301 Shower faucet, 58080301(2024):58080301 Shower faucet:379360
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - General - Author: BIMStone; BIMObjectName: 58080301(2024); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 1111; ETIM Class Number: EC011329 Shower mixing tap; Noise Class: I (ISO 3822); UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/58080301; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL Materials Declaration: http://www.hansa.com/fileadmin/resources/198293_58080301_materialsdeclaration.pdf; URL REACH: http://static.hansa.com/doc/reach; URL UWL: http://static.hansa.com/UWL/58080301
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Backflow Prevention EN1717: EB; Connection: Eccentric coupling(s);Cover plate(s);Silencer(s); Connection Size: G3/4; Eco Flow At 300kPa: 0.25 dm3/s; Flow Rate At 300kPa: 0.29 dm3/s; Installation Type: Wall mounted; Installation Width: 150 ± 15 mm; Lever Handle: Temperature control handle;Flow control handle;Hot/Cold symbols;Eco feature for water flow; Max. Hot Water Supply: 80 C; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Surface treatment: Chrome; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Dimensions - NominalDepth: 103.982 mm; NominalHeight: 100.184 mm; NominalWidth: 300.3 mm
Type - Identity Data - 3D View: https://static.hansa.com/3D/58080301; Catalog Drawing URL: http://static.hansa.com/catdrw/58080301; Category B2C: Shower solutions; Dimension Drawing URL: http://static.hansa.com/dimdrw/58080301; FDV Document URL: http://www.hansa.com/datasheet/58080301/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/58080301; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/58080301; Interactive AR View URL: https://static.hansa.com/AR/58080301; Lifestyle photo: http://static.hansa.com/lifestyle/58080301; Long Marketing: HANSAPRISMA. A Harmony of Simplicity and Elegance. The timeless silhouette of an ancient, handcrafted bridge, perfectly mirrored in tranquil waters, evolves into a slender and elegant cylindric thermostat. Meticulously designed handles seamlessly complete the form without compromising functionality, exuding elegance from every angle. Crafted to echo the refined elements of nature, this design uplifts any bathroom space. Elegant and functional, it reflects the essence of the HANSAPRISMA ELEVATING YOUR MOMENTS; Manufacturer: HANSA; Market: International;Poland;Germany;Austria;Switzerland;Belgium;Netherlands;Czech Republic;Slovakia;Italy; Mobile Product Information URL: http://mpi.hansa.com/58080301; Model: 58080301 Shower faucet; Name_en: 58080301 Shower faucet; OmniClass Number: 23.45.55.00; Product Code: 58080301; Product Family: HANSAPRISMA; Product Image URL: http://static.hansa.com/image/58080301; Product URL: http://static.hansa.com/58080301; Spare-Part Information URL: http://static.hansa.com/sp/58080301; Technical DataSheet URL: http://www.hansa.com/datasheet/58080301/en; Type Name: 58080301 Shower faucet; Warranty Information URL: http://warranty.hansa.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 58080301(2024); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 58080301; Name: 58080301 Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 220 x 240 x 180 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 58080301; Manufacturer: HANSA
Type - Pset_ProductRequirements - Name: 58080301 Shower faucet
Type - Pset_ValveTypeCommon - ValvePattern: OTHER; ValveOperation: OTHER; ValveMechanism: OTHER; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>, Chrome
Pset_DistributionFlowElementCommon - Reference: 58080301 Shower faucet; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Dimensions - Area: 0.0574622 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00188418 m3
Identity Data - Mark: 14
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 58080301(2024); Family and Type: 58080301(2024): 58080301 Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 58080301 Shower faucet; Type Id: 379344; WarrantyStartDate: n/a
